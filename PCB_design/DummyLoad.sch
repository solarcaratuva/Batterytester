File: PCB_design/DummyLoad.sch (KiCad schematic (older format))
At the start: 50 parts

Commit message: stuff.
Parts:
- BATT1: footprint (none) -> Library:18650
- renumbered C2 to CA2
